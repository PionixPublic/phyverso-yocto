require phytec-base-bundle.inc
RAUC_SLOT_rootfs ?= "phyverso-everest-image"
