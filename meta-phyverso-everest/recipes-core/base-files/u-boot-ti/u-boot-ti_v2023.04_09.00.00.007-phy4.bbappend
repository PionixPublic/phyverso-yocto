FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-flash_emmc-script-enable-rauc-boot.patch"

