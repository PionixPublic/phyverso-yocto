PV = "1.15"
SRC_URI[sha256sum] = "655ade57fa703fb421c2eb9a0113b5064bddb145d415dd1f88c79353d90d511a"
LIC_FILES_CHKSUM = "file://readme.txt;beginline=27;endline=50;md5=dcdaac34a3ec1dbb026b4a9b624d6848"