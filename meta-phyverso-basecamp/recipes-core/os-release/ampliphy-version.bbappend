RPROVIDES:${PN} = ""
RREPLACES:${PN} = ""
RCONFLICTS:${PN} = ""