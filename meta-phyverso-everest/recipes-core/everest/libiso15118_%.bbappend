# latest libiso15118 on everest-core/main
SRCREV = "fb8f61b4e68c39890025cb64fdcd2ee23a68c217"