EXTRA_OECMAKE += "\
    -DUSING_TPM2=ON \
"