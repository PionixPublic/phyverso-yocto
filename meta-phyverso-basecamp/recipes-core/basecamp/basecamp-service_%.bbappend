SRC_URI = "file://basecamp.service"