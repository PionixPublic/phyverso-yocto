FILESEXTRAPATHS:append = "${OEROOT}/../../source/meta-arm/meta-arm/recipes-security/optee/optee-os:"