require recipes-images/bundles/phytec-base-bundle.inc
RAUC_SLOT_rootfs ?= "phyverso-everest-image"

CERT_PATH = "${OEROOT}/../phytec-dev-ca"